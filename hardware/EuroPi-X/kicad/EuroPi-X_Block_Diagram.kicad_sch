File: hardware/EuroPi-X/kicad/EuroPi-X_Block_Diagram.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: save and export
Other:
- note added: "Level Shifter"
